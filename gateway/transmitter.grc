options:
  parameters:
    author: Cartof
    generate_options: no_gui
    id: untitled
    output_language: python
    title: Transmitter
  states: {}

blocks:
- name: CR
  id: variable
  parameters:
    value: '1'
  states: {}
- name: SW
  id: variable
  parameters:
    value: '0x12'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '433175000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: implicit_header
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '12'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("HELLO!!")
    period: '1000'
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: 'False'
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: '1'
    sf: '7'
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: CR
    has_crc: 'False'
    impl_head: implicit_header
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: CR
    ldro: '2'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bandwidth
    frame_zero_padd: int(20*2**sf*rate/bandwidth)
    preamb_len: '8'
    samp_rate: rate
    sf: sf
    sync_words: '18'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'False'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: bb_gain
    freq0: center_freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_sdr_whitening_0, msg]
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', osmosdr_sink_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
